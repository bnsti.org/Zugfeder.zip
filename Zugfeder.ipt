# Autodesk Inventor part: Zugfeder
## iProperties
Created: 2008-08
Part Number: Zugfeder
Document SubType Name: Modeling
Designer: U.Rapp
Author: U.Rapp
## Feature names
1. Spirale1
2. Sweeping
